# IAR project USBH_MTP.ewp, settings and files
configuration STM322xG-EVAL_USBH-FS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F217IG ST STM32F217IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F217xx; USE_STM322xG_EVAL; USE_USB_FS
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\BSP\STM322xG_EVAL; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F2xx\Include; ..\..\..\..\..\..\Drivers\STM32F2xx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MTP\Inc; ..\..\..\..\..\..\Utilities\Log
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_HID.bin
  ILINK.IlinkOutputFile: STM322xG-EVAL_USBH-FS.out
  ILINK.IlinkIcfFile: stm32f217xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM322xG-EVAL_USBH-HS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F217xx; USE_STM322xG_EVAL; USE_USB_HS
  group Application/EWARM
    ./: startup_stm32f217xx.s
  group Application/User
    ../Src/: audio.c main.c menu.c mtp.c stm32f2xx_it.c usbh_conf.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../../../../../../Drivers/BSP/Components/ili9320/: ili9320.c
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/BSP/STM322xG_EVAL
    ../../../../../../Drivers/BSP/STM322xG_EVAL/: stm322xg_eval.c stm322xg_eval_audio.c stm322xg_eval_io.c stm322xg_eval_lcd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_hcd.c stm32f2xx_hal_i2c.c stm32f2xx_hal_i2s.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_sram.c stm32f2xx_hal_uart.c stm32f2xx_ll_fsmc.c stm32f2xx_ll_usb.c
  group Middlewares/STM32_USBH_Library/Class/MTP
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MTP/Src/: usbh_mtp.c usbh_mtp_ptp.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
