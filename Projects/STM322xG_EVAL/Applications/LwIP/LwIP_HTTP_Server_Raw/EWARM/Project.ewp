# IAR project Project.ewp, settings and files
configuration STM322xG_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F217IG ST STM32F217IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F217xx; USE_STM322xG_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F2xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32F2xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM322xG_EVAL; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\ipv4; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system\noOS; ..\..\..\..\..\..\Utilities; ..\..\..\..\..\..\Utilities\Log
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f217xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f217xx.s
  group Application/User
    ../Src/: app_ethernet.c ethernetif.c fs.c httpd.c httpd_cgi_ssi.c main.c stm32f2xx_hal_msp.c stm32f2xx_it.c
  group Application/Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Docs
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ili9320/: ili9320.c
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/BSP/STM322xG_EVAL
    ../../../../../../Drivers/BSP/STM322xG_EVAL/: stm322xg_eval.c stm322xg_eval_io.c stm322xg_eval_lcd.c stm322xg_eval_sram.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_sram.c stm32f2xx_hal_uart.c stm32f2xx_ll_fsmc.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: etharp.c
