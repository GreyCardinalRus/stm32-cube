# IAR project Project.ewp, settings and files
configuration STM32F0308-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F030x8; USE_HAL_DRIVER; USE_STM320308_DISCO
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F0308-Discovery; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Utilities\Log; ..\..\..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F0308-Discovery.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f030x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c
  group Example/EWARM
    ./: startup_stm32f030x8.s
  group Drivers/BSP/STM32F0308-Discovery
    ../../../../../../Drivers/BSP/STM32F0308-Discovery/: stm32f0308_discovery.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_rcc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
